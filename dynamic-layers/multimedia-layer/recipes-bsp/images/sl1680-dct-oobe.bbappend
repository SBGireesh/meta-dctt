require ${COREBASE}/../meta-synaptics/dynamic-layers/multimedia-layer/recipes-bsp/images/astra-media-multimedia-common.inc
