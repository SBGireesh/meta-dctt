require ${COREBASE}/../meta-synaptics/dynamic-layers/openembedded-layer/recipes-bsp/images/astra-media-openembedded-common.inc
