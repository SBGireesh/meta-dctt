PACKAGE_INSTALL:append:sl1640usb_dct = " ${ADBD_RPACKAGES} \
                            synasdk-drivers-i2c-dyndmx-pinctrl"
PACKAGE_INSTALL:append:sl1680spi_dct = " initramfs-module-debug"

PACKAGE_INSTALL:append:sl1680usb_dct = " ${ADBD_RPACKAGES} \
                            synasdk-drivers-i2c-dyndmx-pinctrl"

