COMPATIBLE_MACHINE:dolphin = "sl1680_dct"
