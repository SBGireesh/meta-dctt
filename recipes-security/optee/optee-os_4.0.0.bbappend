COMPATIBLE_MACHINE:dolphin = "sl1680_dct"
EARLY_TA_CFG:sl1680spi_dct = ""
